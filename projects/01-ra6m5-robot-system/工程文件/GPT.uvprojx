# Keil uVision project GPT.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BG Renesas
  pack: Renesas.RA_DFP.6.3.0
  cpu: IRAM(0x20000000,0x080000) IROM(0x00000000,0x180000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: UART +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out" && echo. > "$Poutput.rasc""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: Optim=1 v6Lang=3 v6LangP=6
  c misc: @./via/rasc_armclang.via
  c include: .\Hardware;.\Hardware\LCD;..\GPT_Hardware communication
  asm misc: --via=./via/rasc_armasm.via
  memory RVCT4: ROM 0x0 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\script\fsp.scat
  link misc: --via=./via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c hal_warmstart.c tempCodeRunnerFile.c
  group Hardware
    ./Hardware/: UART.c UART.h SysTick.c SysTick.h SPI.c SPI.h GPT.c GPT.h Hardware_IIC.c Hardware_IIC.h software_iic.c software_iic.h Encoder.h Encoder.c Wheel_control.c Wheel_control.h Key.c Key.h ADC.c ADC.h steering_command.c steering_command.h menu.c menu.h Navigation.c Navigation.h Mechanical_hand_control.c Mechanical_hand_control.h Calibration.c Calibration.h Vision_Uart9_Comm.c Vision_Uart9_Comm.h Robot_Control.c Robot_Control.h
  group LCD
    ./Hardware/LCD/: lcd.c lcd.h lcd_init.c lcd_init.h lcdfont.h pic.h
software components: Flex Software:RA Configuration 1.0.0
